# Autodesk Inventor part: Sockel
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2021-06
Part Number: Sockel
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Sockel v9
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
